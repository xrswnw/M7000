<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Boot\OSIO\Boot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\M7000.ewp</path>
  </project>
  <batchBuild/>
</workspace>


